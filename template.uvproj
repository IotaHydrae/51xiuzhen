# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib;.\src\input
  group src
    ./: STARTUP.A51
    ./src/: game_engine.c game_logic.c gpio_spi.c main.c oled.c uart.c
    ./src/input/: encoder.c
  group lib
    ./lib/: data_type.h game_engine.h game_logic.h gpio_spi.h head.h oled.h oledfont.h p4.h uart.h wdt.h
    ./src/input/: encoder.h
